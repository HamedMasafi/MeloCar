File: p/car/car.kicad_pcb (KiCad board)
At the start: 2 copper layers, 3 parts

Commit message: larger via
Other:
- board text added: "+/- BI RO RI"
- board text removed: "BI RO RI"
